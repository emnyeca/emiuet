# Repository emnyeca/emiuet

File README.md:

# Emiuet (EUB-04)

Fretboard-style MIDI instrument for guitarists.

## What Emiuet is

**Emiuet** is a 6 × 13 fretboard MIDI controller built around the way guitarists
think: strings, fret positions, chord shapes, voicings, and controlled expressive
gestures. It is not intended to become a general-purpose pad controller or a
piano-style keyboard.

The thirteen positions preserve familiar guitar-derived voicings without forcing
octave shifts or omissions. Expressive controls are deliberately constrained so
that performance remains predictable: Pitch Bend is upward-only, and the optional
MPE-style mode separates strings by MIDI channel rather than attempting a fully
general per-note control system.

Emiuet is part of **Emnyeca's Utility Build Series (EUB)**. The project prioritizes
musical intent, reliability, and a clear physical mental model over feature breadth.

## Playing surface and controls

- 6 strings × 13 positions: 78 low-profile keys
- Three sliders: Velocity, CC#1 Modulation, and upward-only Pitch Bend
- Constrained stringwise MPE-style performance mode
- Minimal OLED feedback designed to avoid distracting from performance
- USB MIDI, Type-A TRS MIDI OUT/IN, and BLE capability
- Auxiliary USB HID Keyboard mode (`TYPE`)
- One RGB LED under each key for fretboard visualization

`TYPE` is a desk-convenience feature for short text, navigation, and shortcuts.
It reuses the physical matrix but does not change Emiuet's identity as a musical
instrument. See [USB HID Keyboard Mode](docs/keyboard-mode.md) for the complete
layout and Fn layer.

## Rev.B hardware summary

Rev.B simplifies Emiuet into a USB-powered Device/UFP:

- ESP32-S3-MINI-1 using native USB
- One USB-C port for 5 V power, USB MIDI, USB HID, and firmware flashing
- Persistent USB MIDI + HID Keyboard composite device
- USB-C CC pull-downs with a comparator that tracks the Source current advertisement
- No USB Host, DRP, Host VBUS sourcing, internal battery, charger, or PowerPath
- SK6812 MINI-E ×78 on one data chain with a 3.3 V-to-5 V buffer
- Firmware-limited LED brightness/current based on conservative USB power budgets

Mobile use is supported with an external USB power bank. A 3 A Source advertisement
does not raise Emiuet's internal design ceiling above approximately 5 V / 1.5 A.

## MIDI and RGB behavior

Performance logic remains independent of individual transports. MIDI generation
must not block on USB, TRS, or BLE output. Incoming USB or TRS Note On/Off messages
can drive fretboard visualization through a transport-independent LED state layer.

The external protocol for device-level LED settings such as global brightness is
not defined yet. Standard musical Control Change messages are not repurposed for
device configuration; a future explicit protocol may use SysEx.

## Hardware and firmware sources

- Current Rev.B schematic draft: `hardware/kicad/Emiuet.kicad_sch`
- Historical Rev.A schematic: `hardware/kicad/Emiuet_RevA.kicad_sch`
- Rev.B GPIO allocation: `docs/pinout-v3.md`
- Current design decisions: `docs/decisions.md`
- Firmware: ESP-IDF 5.3.4 + FreeRTOS; OLED rendering uses u8g2

The checked-in PCB layout is historical Rev.A data and was not updated with the
Rev.B schematic. Rev.B placement and routing require a separate PCB redesign.

## Project status

The Rev.B schematic is an early architecture draft, not a fabrication-ready release.
USB-C current detection, reset/boot, the RGB buffer, and the OLED connector are
drawn; power and MIDI circuits are incomplete, and the matrix, sliders, buttons,
and protection circuits still need implementation. Component selection, footprints, PCB layout,
and physical validation remain open engineering work.

## License

To be determined. An open-source-friendly license is planned after prototype
validation.

## KiCad design hardware/kicad/Emiuet.kicad_pcb

File hardware/kicad/README.md:

# KiCad sourceの位置づけ

- `Emiuet.kicad_sch`: 現行Rev.B schematic architecture draft（KiCad 10形式）
- `Emiuet_RevA.kicad_sch`: Rev.A historical schematic
- `Emiuet.kicad_pcb`: Rev.A historical PCB layout。今回のRev.B作業では未変更

Rev.B schematicとRev.A PCBはconnectivityが一致しません。historical boardに対してschematicからPCB updateを実行しないでください。Rev.B placement/routingは別のPCB redesignとして行います。

Rev.B draftではsingle USB-C UFP/power path、CC Rd＋comparatorによる電流広告検出、ESP32-S3 GPIO nets、3.3 V regulator候補、RGB level shifter、78-pixel serpentine data chain、bulk/local bypass方針、TRS MIDI IN/OUT、OLED connector、matrix/UI busesを確認できます。

これはproduction releaseではありません。reset/BOOT、CC検出、RGB bufferの電源接続とidle bias、OLED connectorを実回路化しました。regulatorとMIDI interfaceは未接続で、matrix/slider/button、input protection、各LEDのlocal bypass等は実回路化が必要です。component selection、footprints、接続設計、ERC確認と実機Validationを経て確定します。

OLED footprint `Eminuet Library:Waveshare_OLED_0.96in_C_7P` はRev.A PCBのBrd2（`EUB_SSD1306:9E6018AD`、B面・180°配置）から形状を変えずに書き出したものです。旧名・説明のAdafruit 1.3 inchは実物と異なります。

初期の実ファイル検証と再設計・EDA評価の記録は [Rev.B監査](../../docs/rev-b-audit.md) にあります（監査時点の状態）。

現在の進捗・再開手順は [ロードマップ](../../docs/rev-b-roadmap.md)、追加回路の根拠と機構条件は [回路ノート](../../docs/rev-b-circuit-notes.md) にあります。`python tools/verify_hardware.py` をリポジトリrootから実行すると、KiCad 10.0.3でERC/netlist/BOM/SVGと入力hashを `build/hardware/` に出力します。違反が残る現状では終了コード1が正常な検出結果です。出力BOMはレビュー用で、発注用ではありません。

Parts:
BT1: 800mAh; Battery Cell 800mah nobis
Brd2: waveshare0.96inch; 9E6018AD
C1, C12, C31: 1μ; C_0603_1608Metric_noSilks
C2: 10μ; C_0603_1608Metric_noSilks
C3, C4, C6, C7, C14, C21, C23, C24, C28, C29: 22μ; C_0603_1608Metric_noSilks
C5, C8, C9, C11, C13, C15, C16, C17, C18, C19, C20, C22, C25, C27, C30: 100n; C_0603_1608Metric_noSilks
C10: 33p; C_0603_1608Metric_noSilks
C26: Byp or Bulk xμ_10μ; C_0603_1608Metric_noSilks
D1: SMF5V0A; D_SOD-123F_noSilk
D1_0, D1_1, D1_2, D1_3, D1_4, D1_5, D1_6, D1_7, D1_8, D1_9, D1_10, D1_11, D1_12, D2_0, D2_1, D2_2, D2_3, D2_4, D2_5, D2_6, D2_7, D2_8, D2_9, D2_10, D2_11, D2_12, D3_0, D3_1, D3_2, D3_3, D3_4, D3_5, D3_6, D3_7, D3_8, D3_9, D3_10, D3_11, D3_12, D4_0, D4_1, D4_2, D4_3, D4_4, D4_5, D4_6, D4_7, D4_8, D4_9, D4_10, D4_11, D4_12, D5_0, D5_1, D5_2, D5_3, D5_4, D5_5, D5_6, D5_7, D5_8, D5_9, D5_10, D5_11, D5_12, D6_0, D6_1, D6_2, D6_3, D6_4, D6_5, D6_6, D6_7, D6_8, D6_9, D6_10, D6_11, D6_12: 1N4148; D_SOD-123_no silks
D3: LED B; LED_D5.0mm THT Turn_noSilk
F1, F2: MF-MSMF110-2; Fuse_1812_4532Metric_noSilk
FB1, FB2: FerriteBead_Small; L_0805_2012Metric_noSilk
H_Center1, H_Center2, H_Center3, H_Center4, H_Center5, H_Center6, H_Center7, H_Center8: MountingHole; MountingHole_2.2mm_M2_jlcpcb
H_Left1, H_Left2, H_Left3, H_Left4: MountingHole; MountingHole_2.2mm_M2_jlcpcb
H_Right1, H_Right2, H_Right3, H_Right4: MountingHole; MountingHole_2.2mm_M2_jlcpcb
J1, J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV_noSilk
J3: AudioJack3; Jack_3.5mm_KoreanHropartsElec_PJ-313D-4A_Horizontal
J4: Conn_01x02_Pin; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical_right+
L1: DLW21SN900SQ2L; L_CommonModeChoke_Coilcraft_0603USB_noSilk
L2: 4.7μ; L_TDK_VLS6045EX_VLS6045AF_noSilk
NT2: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q1: S9013 J3; SOT-23_noSilk
R1, R6, R10, R25, R26: 10k; R_0603_1608Metric_noSilks
R2, R3: 5.1k; R_0603_1608Metric_noSilks
R4, R9: 220; R_0603_1608Metric_noSilks
R5: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R7, R8: 470; R_0603_1608Metric_noSilks
R11: 900k; R_0603_1608Metric_noSilks
R12, R17, R18: 4.7k; R_0603_1608Metric_noSilks
R13: 887k; R_0603_1608Metric_noSilks
R14: 120k; R_0603_1608Metric_noSilks
R15: 200k; R_1206_3216Metric_noSilk
R16: 200k; R_0603_1608Metric_noSilks
R19, R20, R21: 100; R_0603_1608Metric_noSilks
R22: 1.18k; R_0603_1608Metric_noSilks
R23: 4.12k; R_0603_1608Metric_noSilks
R24: 1.13k; R_0603_1608Metric_noSilks
R27: 560k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R28: 1k; R_0603_1608Metric_noSilks
R29: 220k; R_0603_1608Metric_noSilks
R30: 100k; R_0603_1608Metric_noSilks
RV1, RV2, RV3: 10k; Potentiometer_Slider_AliExpress_10k_35mm
SW1: SW_Slide_DPDT; SW_SK22D02_DPDT_Angled
SW1_0, SW1_1, SW1_2, SW1_3, SW1_4, SW1_5, SW1_6, SW1_7, SW1_8, SW1_9, SW1_10, SW1_11, SW1_12, SW2_0, SW2_1, SW2_2, SW2_3, SW2_4, SW2_5, SW2_6, SW2_7, SW2_8, SW2_9, SW2_10, SW2_11, SW2_12, SW3_0, SW3_1, SW3_2, SW3_3, SW3_4, SW3_5, SW3_6, SW3_7, SW3_8, SW3_9, SW3_10, SW3_11, SW3_12, SW4_0, SW4_1, SW4_2, SW4_3, SW4_4, SW4_5, SW4_6, SW4_7, SW4_8, SW4_9, SW4_10, SW4_11, SW4_12, SW5_0, SW5_1, SW5_2, SW5_3, SW5_4, SW5_5, SW5_6, SW5_7, SW5_8, SW5_9, SW5_10, SW5_11, SW5_12, SW6_0, SW6_1, SW6_2, SW6_3, SW6_4, SW6_5, SW6_6, SW6_7, SW6_8, SW6_9, SW6_10, SW6_11, SW6_12: Switch_SW_Push; SW_Hotswap_Kailh_Choc_noD_reflect
SW2: SW_SPST; Akidsuki_WhiteCircleTactileSwitch
SW3, SW4: SW_SPST; SW_PUSH_6mm_H9.5mm_DTS65
SW5, SW6: SW_SPST; SW_SPST_TS-1088-xR020
SW7, SW8: SW_SPDT; SW_SPDT_Shouhan_MSK12C02
TH1: Thermistor; R_0603_1608Metric_noSilks
TP1, TP3, TP4, TP5: TestPoint; TestPoint_Pad_D1.0mm
U1: ESP32-S3-MINI-1; ESP32-S2-MINI-1_thermalVia_noSilk
U2: TPD2EUSB30ADRTR; Texas_DRT-3_noSilk
U3: LM66100DCK; SOT-363_SC-70-6_noSilk
U4: AP7333-33SAG-7; SOT-23_noSilk
U5: TUSB320LAIRWBR; Texas_X2QFN-12_1.6x1.6mm_P0.4mm_noSilk
U6: TPS61023DRLR; SOT-563_noSilk
U7: BQ24074RGT; BQ24074_QFN-16_3x3mm_withThermalVia_noSilk

Connections:
+5V: C2.1, C4.1, C6.1, C7.1, C8.1, C9.1, C10.1, R9.1, R10.2, R13.1, U3.1 (VIN), U4.1 (VI), U6.6 (VOUT)
BAT_VSENSE: C27.1, R28.2, U1.21 (IO17)
BAT_VSENSE_RAW: R27.2, R28.1, R29.2
CHG: R25.1, SW1.6 (C), U1.30 (IO48), U7.9 (~CHG)
D+: L1.2, U1.24 (USB_D+)
D-: L1.3, U1.23 (USB_D-)
FLASH_RX: R8.1, U1.40 (RXD0)
FLASH_TX: R7.2, U1.39 (TXD0)
Frt0: D1_0.1 (K), D2_0.1 (K), D3_0.1 (K), D4_0.1 (K), D5_0.1 (K), D6_0.1 (K), U1.44 (IO46)
Frt1: D1_1.1 (K), D2_1.1 (K), D3_1.1 (K), D4_1.1 (K), D5_1.1 (K), D6_1.1 (K), U1.41 (IO45)
Frt2: D1_2.1 (K), D2_2.1 (K), D3_2.1 (K), D4_2.1 (K), D5_2.1 (K), D6_2.1 (K), U1.31 (IO35)
Frt3: D1_3.1 (K), D2_3.1 (K), D3_3.1 (K), D4_3.1 (K), D5_3.1 (K), D6_3.1 (K), U1.32 (IO36)
Frt4: D1_4.1 (K), D2_4.1 (K), D3_4.1 (K), D4_4.1 (K), D5_4.1 (K), D6_4.1 (K), U1.33 (IO37)
Frt5: D1_5.1 (K), D2_5.1 (K), D3_5.1 (K), D4_5.1 (K), D5_5.1 (K), D6_5.1 (K), U1.29 (IO34)
Frt6: D1_6.1 (K), D2_6.1 (K), D3_6.1 (K), D4_6.1 (K), D5_6.1 (K), D6_6.1 (K), U1.28 (IO33)
Frt7: D1_7.1 (K), D2_7.1 (K), D3_7.1 (K), D4_7.1 (K), D5_7.1 (K), D6_7.1 (K), U1.27 (IO47)
Frt8: D1_8.1 (K), D2_8.1 (K), D3_8.1 (K), D4_8.1 (K), D5_8.1 (K), D6_8.1 (K), U1.25 (IO21)
Frt9: D1_9.1 (K), D2_9.1 (K), D3_9.1 (K), D4_9.1 (K), D5_9.1 (K), D6_9.1 (K), U1.19 (IO15)
Frt10: D1_10.1 (K), D2_10.1 (K), D3_10.1 (K), D4_10.1 (K), D5_10.1 (K), D6_10.1 (K), U1.18 (IO14)
Frt11: D1_11.1 (K), D2_11.1 (K), D3_11.1 (K), D4_11.1 (K), D5_11.1 (K), D6_11.1 (K), U1.17 (IO13)
Frt12: D1_12.1 (K), D2_12.1 (K), D3_12.1 (K), D4_12.1 (K), D5_12.1 (K), D6_12.1 (K), U1.16 (IO12)
GNDA: C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, J4.2, NT2.2, R22.1, R23.1, R24.1, R29.1, RV1.1, RV2.1, RV3.1, SW2.1 (A), SW3.1 (A), SW4.1 (A), TH1.2, U7.4 (~CE), U7.5 (EN2), U7.8 (VSS), U7.14 (TMR), U7.17 (VSS)
GNDD: Brd2.6 (GND), C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.1, C12.1, C13.2, C14.2, C28.2, C29.2, C30.2, C31.1, D1.2 (A2), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.S, NT2.1, Q1.2 (E), R2.2, R3.2, R12.2, R14.1, R30.1, SW5.2 (B), SW6.2 (B), TP1.1, TP4.1, U1.1 (GND), U1.2 (GND), U1.42 (GND), U1.43 (GND), U1.46 (GND), U1.47 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U1.53 (GND), U1.54 (GND), U1.55 (GND), U1.56 (GND), U1.57 (GND), U1.58 (GND), U1.59 (GND), U1.60 (GND), U1.61 (GND), U1.62 (GND), U1.63 (GND), U1.64 (GND), U1.65 (GND), U2.3 (GND), U3.2 (GND), U4.3 (GND), U5.10 (GND), U5.11 (~EN), U6.4 (GND)
LED: SW1.4 (A), U1.10 (IO6)
unnamed: D1.1 (A1), F2.2, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: D1_0.2 (A), SW1_0.2
unnamed: D1_1.2 (A), SW1_1.2
unnamed: D1_2.2 (A), SW1_2.2
unnamed: D1_3.2 (A), SW1_3.2
unnamed: D1_4.2 (A), SW1_4.2
unnamed: D1_5.2 (A), SW1_5.2
unnamed: D1_6.2 (A), SW1_6.2
unnamed: D1_7.2 (A), SW1_7.2
unnamed: D1_8.2 (A), SW1_8.2
unnamed: D1_9.2 (A), SW1_9.2
unnamed: D1_10.2 (A), SW1_10.2
unnamed: D1_11.2 (A), SW1_11.2
unnamed: D1_12.2 (A), SW1_12.2
unnamed: D2_0.2 (A), SW2_0.2
unnamed: D2_1.2 (A), SW2_1.2
unnamed: D2_2.2 (A), SW2_2.2
unnamed: D2_3.2 (A), SW2_3.2
unnamed: D2_4.2 (A), SW2_4.2
unnamed: D2_5.2 (A), SW2_5.2
unnamed: D2_6.2 (A), SW2_6.2
unnamed: D2_7.2 (A), SW2_7.2
unnamed: D2_8.2 (A), SW2_8.2
unnamed: D2_9.2 (A), SW2_9.2
unnamed: D2_10.2 (A), SW2_10.2
unnamed: D2_11.2 (A), SW2_11.2
unnamed: D2_12.2 (A), SW2_12.2
unnamed: D3.2 (A), R5.1
unnamed: D3.1 (K), SW1.5 (B)
unnamed: D3_0.2 (A), SW3_0.2
unnamed: D3_1.2 (A), SW3_1.2
unnamed: D3_2.2 (A), SW3_2.2
unnamed: D3_3.2 (A), SW3_3.2
unnamed: D3_4.2 (A), SW3_4.2
unnamed: D3_5.2 (A), SW3_5.2
unnamed: D3_6.2 (A), SW3_6.2
unnamed: D3_7.2 (A), SW3_7.2
unnamed: D3_8.2 (A), SW3_8.2
unnamed: D3_9.2 (A), SW3_9.2
unnamed: D3_10.2 (A), SW3_10.2
unnamed: D3_11.2 (A), SW3_11.2
unnamed: D3_12.2 (A), SW3_12.2
unnamed: D4_0.2 (A), SW4_0.2
unnamed: D4_1.2 (A), SW4_1.2
unnamed: D4_2.2 (A), SW4_2.2
unnamed: D4_3.2 (A), SW4_3.2
unnamed: D4_4.2 (A), SW4_4.2
unnamed: D4_5.2 (A), SW4_5.2
unnamed: D4_6.2 (A), SW4_6.2
unnamed: D4_7.2 (A), SW4_7.2
unnamed: D4_8.2 (A), SW4_8.2
unnamed: D4_9.2 (A), SW4_9.2
unnamed: D4_10.2 (A), SW4_10.2
unnamed: D4_11.2 (A), SW4_11.2
unnamed: D4_12.2 (A), SW4_12.2
unnamed: D5_0.2 (A), SW5_0.2
unnamed: D5_1.2 (A), SW5_1.2
unnamed: D5_2.2 (A), SW5_2.2
unnamed: D5_3.2 (A), SW5_3.2
unnamed: D5_4.2 (A), SW5_4.2
unnamed: D5_5.2 (A), SW5_5.2
unnamed: D5_6.2 (A), SW5_6.2
unnamed: D5_7.2 (A), SW5_7.2
unnamed: D5_8.2 (A), SW5_8.2
unnamed: D5_9.2 (A), SW5_9.2
unnamed: D5_10.2 (A), SW5_10.2
unnamed: D5_11.2 (A), SW5_11.2
unnamed: D5_12.2 (A), SW5_12.2
unnamed: D6_0.2 (A), SW6_0.2
unnamed: D6_1.2 (A), SW6_1.2
unnamed: D6_2.2 (A), SW6_2.2
unnamed: D6_3.2 (A), SW6_3.2
unnamed: D6_4.2 (A), SW6_4.2
unnamed: D6_5.2 (A), SW6_5.2
unnamed: D6_6.2 (A), SW6_6.2
unnamed: D6_7.2 (A), SW6_7.2
unnamed: D6_8.2 (A), SW6_8.2
unnamed: D6_9.2 (A), SW6_9.2
unnamed: D6_10.2 (A), SW6_10.2
unnamed: D6_11.2 (A), SW6_11.2
unnamed: D6_12.2 (A), SW6_12.2
unnamed: F1.1, FB2.2
unnamed: F1.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: F2.1, FB1.2
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R3.1
unnamed: J3.T, R9.2
unnamed: C26.1, J4.1, R27.1, U7.2 (BAT), U7.3 (BAT)
unnamed: Q1.1 (B), R4.2, R30.2
unnamed: J3.R, Q1.3 (C)
unnamed: R19.1, RV1.2
unnamed: R20.1, RV2.2
unnamed: R21.1, RV3.2
unnamed: C31.2, R1.1, SW5.1 (A), U1.45 (EN)
unnamed: SW7.1 (A), TP3.1
unnamed: R7.1, SW7.2 (B)
unnamed: SW8.1 (A), TP5.1
unnamed: R8.2, SW8.2 (B)
unnamed: R10.1, U3.3 (~CE)
unnamed: R12.1, U5.5 (ADDR)
unnamed: R16.2, U5.9 (ID)
unnamed: C5.1, R11.1, U5.4 (VBUS_DET)
unnamed: R15.2, U5.6 (~INT/OUT3)
unnamed: C10.2, R13.2, R14.2, U6.1 (FB)
unnamed: L2.2, U6.5 (SW)
unnamed: R22.2, U7.12 (ILIM)
unnamed: R24.2, U7.16 (ISET)
unnamed: R23.2, U7.15 (ITERM)
unnamed: TH1.1, U7.1 (TS)
PGOOD: R26.1, U1.34 (IO38), U7.7 (~PGOOD)
SCL: Brd2.4 (CLK), R17.2, U1.20 (IO16), U5.8 (SCL/OUT2)
SDA: Brd2.5 (DIN), R18.2, U1.22 (IO18), U5.7 (SDA/OUT1)
SLDR1: C15.1, R19.2, U1.8 (IO4)
SLDR2: C16.1, R20.2, U1.6 (IO2)
SLDR3: C17.1, R21.2, U1.5 (IO1)
SW_CENTER: C18.1, SW2.2 (B), U1.36 (IO40)
SW_LEFT: C20.1, SW4.2 (B), SW8.3 (C)
SW_RIGHT: C19.1, SW3.2 (B), U1.35 (IO39)
SYS: C23.1, C24.1, C25.1, R5.2, SW1.2 (B), U7.10 (OUT), U7.11 (OUT)
SYS_SW: C28.1, C29.1, C30.1, L2.1, SW1.3 (C), U6.2 (EN), U6.3 (VIN)
Str1: SW1_0.1, SW1_1.1, SW1_2.1, SW1_3.1, SW1_4.1, SW1_5.1, SW1_6.1, SW1_7.1, SW1_8.1, SW1_9.1, SW1_10.1, SW1_11.1, SW1_12.1, U1.9 (IO5)
Str2: SW2_0.1, SW2_1.1, SW2_2.1, SW2_3.1, SW2_4.1, SW2_5.1, SW2_6.1, SW2_7.1, SW2_8.1, SW2_9.1, SW2_10.1, SW2_11.1, SW2_12.1, U1.11 (IO7)
Str3: SW3_0.1, SW3_1.1, SW3_2.1, SW3_3.1, SW3_4.1, SW3_5.1, SW3_6.1, SW3_7.1, SW3_8.1, SW3_9.1, SW3_10.1, SW3_11.1, SW3_12.1, U1.12 (IO8)
Str4: SW4_0.1, SW4_1.1, SW4_2.1, SW4_3.1, SW4_4.1, SW4_5.1, SW4_6.1, SW4_7.1, SW4_8.1, SW4_9.1, SW4_10.1, SW4_11.1, SW4_12.1, U1.13 (IO9)
Str5: SW5_0.1, SW5_1.1, SW5_2.1, SW5_3.1, SW5_4.1, SW5_5.1, SW5_6.1, SW5_7.1, SW5_8.1, SW5_9.1, SW5_10.1, SW5_11.1, SW5_12.1, U1.15 (IO11)
Str6: SW6_0.1, SW6_1.1, SW6_2.1, SW6_3.1, SW6_4.1, SW6_5.1, SW6_6.1, SW6_7.1, SW6_8.1, SW6_9.1, SW6_10.1, SW6_11.1, SW6_12.1, U1.14 (IO10)
TXD: R4.1, SW7.3 (C)
USB1_VBUS: C21.1, C22.1, FB2.1, U7.13 (IN)
USB2_CC1: J2.A5 (CC1), U5.1 (CC1)
USB2_CC2: J2.B5 (CC2), U5.2 (CC2)
USB2_D+: J2.A6 (D+), L1.1, U2.1 (D+)
USB2_D-: J2.A7 (D-), L1.4, U2.2 (D-)
VBUS2: C3.1, FB1.1, R11.2, U3.6 (VOUT)

Notes on the sheet:
安定3.3V
USB2 保護
コモンドチョーク
理想ダイオード／逆流防止スイッチ
ESD保護素子(USB端子から最短)
FLAS用UART確保
昇圧型DC/DCコンバータ
USBのCCライン制御
安定5V
バッテリー充電管理と電源の切り替え
同じ長さにする
TRS MIDI TypeA 信号線を要確認
Analog GND
電源トグル/充電監視LED
右側インターフェイス
データ/電源両用USB USB2
3.3 V 低ドロップアウトレギュレータ（LDO）
電源供給専用USB USB1
左側インターフェイス

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
Board: 2 copper layers, 297.0 x 102.4 mm, 272 parts (13 on the bottom side), 159 nets.

File hardware/kicad/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BRD2,9E6018AD,1,waveshare0.96inch,
BT1,Battery Cell 800mah bis,1,800mAh,
"C1, C12",0603,2,1μ,
C10,0603,1,33p,
"C11, C13, C15, C16, C17, C18, C19, C20, C22, C25, C27, C30, C5, C8, C9",0603,15,100n,
"C14, C21, C23, C24, C28, C29, C3, C4, C6, C7",0603,10,22μ,
C2,0603,1,10μ,
C26,0603,1,Byp or Bulk xμ_10μ,
D1,D_SOD-123F_noSilk,1,SMF5V0A,
"D1_0, D1_1, D1_10, D1_11, D1_12, D1_2, D1_3, D1_4, D1_5, D1_6, D1_7, D1_8, D1_9, D2_0, D2_1, D2_10, D2_11, D2_12, D2_2, D2_3, D2_4, D2_5, D2_6, D2_7, D2_8, D2_9, D3_0, D3_1, D3_10, D3_11, D3_12, D3_2, D3_3, D3_4, D3_5, D3_6, D3_7, D3_8, D3_9, D4_0, D4_1, D4_10, D4_11, D4_12, D4_2, D4_3, D4_4, D4_5, D4_6, D4_7, D4_8, D4_9, D5_0, D5_1, D5_10, D5_11, D5_12, D5_2, D5_3, D5_4, D5_5, D5_6, D5_7, D5_8, D5_9, D6_0, D6_1, D6_10, D6_11, D6_12, D6_2, D6_3, D6_4, D6_5, D6_6, D6_7, D6_8, D6_9",D_SOD-123_no silks,78,1N4148,
D3,LED_D5.0mm THT Turn_noSilk,1,LED B,
"F1, F2",1812,2,MF-MSMF110-2,
"FB1, FB2",0805,2,FerriteBead_Small,
"J1, J2",USB_C_Receptacle_G-Switch_GT-USB-7010ASV_noSilk,2,USB_C_Receptacle_USB2.0_16P,
J3,Jack_3.5mm_KoreanHropartsElec_PJ-313D-4A_Horizontal,1,AudioJack3,
J4,JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical_right+,1,Conn_01x02_Pin,
JP1,TestPoint_2Pads_Pitch2.54mm_Drill0.8mm,1,Jumper_2_Bridged,
JP3,SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm,1,Jumper_2_Bridged,
L1,L_CommonModeChoke_Coilcraft_0603USB_noSilk,1,DLW21SN900SQ2L,
L2,L_TDK_VLS6045EX_VLS6045AF_noSilk,1,4.7μ,
Q1,SOT-23_noSilk,1,S9013 J3,
"R1, R10, R25, R26",0603,4,10k,
R11,0603,1,900k,
"R12, R17, R18",0603,3,4.7k,
R13,0603,1,887k,
R14,0603,1,120k,
R15,1206,1,200k,
R16,0603,1,200k,
"R19, R20, R21",0603,3,100,
"R2, R3",0603,2,5.1k,
R22,0603,1,1.18k,
R23,0603,1,4.12k,
R24,0603,1,1.13k,
R27,R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal,1,560k,
R28,0603,1,1k,
R29,0603,1,220k,
"R4, R9",0603,2,220,
R5,R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal,1,1k,
"RV1, RV2, RV3",Potentiometer_Slider_AliExpress_10k_35mm,3,10k,
SW1,SW_SK22D02_DPDT_Angled,1,SW_Slide_DPDT,
"SW1_0, SW1_1, SW1_10, SW1_11, SW1_12, SW1_2, SW1_3, SW1_4, SW1_5, SW1_6, SW1_7, SW1_8, SW1_9, SW2_0, SW2_1, SW2_10, SW2_11, SW2_12, SW2_2, SW2_3, SW2_4, SW2_5, SW2_6, SW2_7, SW2_8, SW2_9, SW3_0, SW3_1, SW3_10, SW3_11, SW3_12, SW3_2, SW3_3, SW3_4, SW3_5, SW3_6, SW3_7, SW3_8, SW3_9, SW4_0, SW4_1, SW4_10, SW4_11, SW4_12, SW4_2, SW4_3, SW4_4, SW4_5, SW4_6, SW4_7, SW4_8, SW4_9, SW5_0, SW5_1, SW5_10, SW5_11, SW5_12, SW5_2, SW5_3, SW5_4, SW5_5, SW5_6, SW5_7, SW5_8, SW5_9, SW6_0, SW6_1, SW6_10, SW6_11, SW6_12, SW6_2, SW6_3, SW6_4, SW6_5, SW6_6, SW6_7, SW6_8, SW6_9",SW_Hotswap_Kailh_Choc_noD_reflect,78,Switch_SW_Push,
SW2,Akidsuki_WhiteCircleTactileSwitch,1,SW_SPST,
"SW3, SW4",SW_PUSH_6mm_H9.5mm_DTS65,2,SW_SPST,
TH1,0603,1,Thermistor,
U1,ESP32-S2-MINI-1_thermalVia_noSilk,1,ESP32-S3-MINI-1,
U2,Texas_DRT-3_noSilk,1,TPD2EUSB30ADRTR,
U3,SOT-363_SC-70-6_noSilk,1,LM66100DCK,
U4,SOT-23_noSilk,1,AP7333-33SAG-7,
U5,Texas_X2QFN-12_1.6x1.6mm_P0.4mm_noSilk,1,TUSB320LAIRWBR,
U6,SOT-563_noSilk,1,TPS61023DRLR,
U7,BQ24074_QFN-16_3x3mm_withThermalVia_noSilk,1,BQ24074RGT,

## Code that names these connections

File firmware/main/oled_demo.c (part):

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// -------------------------
// Power UI / Debug inputs
// -------------------------
#define PIN_PGOOD           ((int)PIN_PGOOD_STATUS)
#define PIN_CHG             ((int)PIN_CHG_STATUS)

#define PIN_DBG_SLIDER      PIN_SLIDER_VEL    // ADC (velocity slider)
#define PIN_DBG_BUTTON      PIN_SW_CENTER     // GPIO input, pull-up, press=0

#define POWER_UPDATE_MS     500

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// -------------------------
static bool s_adc_ok = false;

// デバッグ用モード（PIN_SW_CENTER 押下で巡回）
static power_debug_mode_t s_dbg_mode = PWR_MODE_BATTERY;

// ボタンデバウンス用
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
    // PGOOD / CHG (pull-up already external, but internal pull-up harmless)
    io.mode = GPIO_MODE_INPUT;
    io.pin_bit_mask = (1ULL << PIN_PGOOD) | (1ULL << PIN_CHG);
    io.pull_up_en = 1;
    io.pull_down_en = 0;
    gpio_config(&io);

    // Debug button (PIN_SW_CENTER)
    io.pin_bit_mask = (1ULL << PIN_DBG_BUTTON);
    io.pull_up_en = 1;
    io.pull_down_en = 0;
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    }

    int mv = 0;
    if (adc_manager_read_mv(PIN_BAT_VSENSE, &mv) != ESP_OK) {
        uint16_t raw = slider_read_pitchbend();
        int slider_mv = (raw * 3300) / 1023;
        return 3300 + (slider_mv * 900) / 3300;
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    return mv; // Vadc
}

// PIN_SW_CENTER 押下ごとに: BATTERY -> EXT -> FAULT -> BATTERY
static void debug_button_update(void)
{
    int now = gpio_get_level(PIN_DBG_BUTTON);
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    debug_button_update();

    // 実ピン読み（デバッグ時は上書き）
    bool ext_power = (gpio_get_level(PIN_PGOOD) == 0);
    bool charging  = (gpio_get_level(PIN_CHG) == 0);

    switch (s_dbg_mode) {
        case PWR_MODE_BATTERY:
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    }

    // ---- Battery mode ----
    /* Read vbat from PIN_BAT_VSENSE.
     * Note: PIN_DBG_SLIDER is reserved for the debug slider/pitch-bend proxy.
     */
    int vbat_mv = read_adc_mv_batvsense(); // read battery sense (mV)
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
File firmware/main/controls.h:

#pragma once

#include <stdint.h>

/* Centralized physical controls (buttons) state/task.
 * Owns PIN_SW_CENTER / PIN_SW_LEFT / PIN_SW_RIGHT.
 */

void controls_start(void);

/* Current octave offset in octaves, clamped to [-3, +3].
 * Intended for note calculation and OLED display.
 */
int8_t controls_get_octave(void);

## Commit log (part)

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2025-12-18 Squashed 'firmware/' content from commit 7a25111
    git-subtree-dir: firmware
    git-subtree-split: 7a251112e31b1e4eea80ba27467c05a75674a2eb
2025-12-18 Add Copilot instructions
2025-12-18 Add design docs
2025-12-18 Add top-level README
2025-12-18 Add hardware project structure
2025-12-18 Add gitignore for KiCad and ESP-IDF
2025-12-18 Add gitattribute
2025-12-18 Fix broken submodule state and stabilize unified repository
2025-12-18 creating workspace, fixing buid configuration
2025-12-18 include u8g2
2025-12-20 adding pinout doc, c, and h
2025-12-20 Stabilize board_pins and boot sequence
    - Fix GPIO assignments and late init
    - Restore boot animation and OLED init
    - Confirm stable boot without reboot loop
2025-12-21 firmware: add non-blocking matrix scanner, MIDI bridge, slider ADC & pitch-bend task, MPE support
    - Add non-blocking matrix_scan (debounce + callback)\n- Add matrix_midi_bridge to convert key events to NoteOn/Off and integrate with MPE\n- Provide midi_out stubs and midi_mpe implementation for per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
2025-12-21 firmware: staged matrix init + robust debounce + boot-safety discard\n\n- Add stable_pressed and transition-only debounce in matrix_scan\n- Add discard_cycles support to ignore early scans (protect s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
2025-12-21 firmware: safety fixes for matrix init and debounce
    - Skip counter updates during initial discard and capture current physical state at discard end\n- Transition-only stable_pressed debounce to avoid repeated NoteOn/Off\n- Split matrix init into prepa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
2025-12-21 slider: add enabled flag and slider_is_enabled(); prevent starting slider task when ADC not configured
2025-12-21 midi/mpe: centralize MPE channel mapping API and use in matrix bridge
2025-12-21 Pitch bend utilization especially for reset attributes
2025-12-21 slider: stabilize ADC reads and state-machine sending; robust ADC failure handling
2025-12-21 matrix: per-string simulator; sim/hw state split; thread-safe matrix state; oled/midi use sim; increase sim task stacks
2025-12-22 Centralize ADC access via adc_manager
    Use adc_manager in slider/OLED to eliminate ADC oneshot unit conflicts.
    Gate USB-MIDI backend on CONFIG_TINYUSB_MIDI_COUNT and keep esp_tinyusb dependency files.
2025-12-22 Apply sdkconfig.defaults for TinyUSB MIDI
    Use SDKCONFIG_DEFAULTS so CONFIG_TINYUSB_MIDI_COUNT=1 is applied on reconfigure/fullclean.
2025-12-22 USB-MIDI: add enumeration logging; set flash size 4MB default
2025-12-22 MPE: base..base+5 clamp; gate simulator default
2025-12-22 Rename OLED/LED UI modules
    oled_demo -> ui_oled; led_status -> ui_led_status (API unchanged)
2025-12-22 TRS MIDI: UART31250 backend
    Add Kconfig gate, UART0 console guard, and drop-rate logging
2025-12-22 MIDI: TRS/USB stability tuning; BLE init fix
    - BLE: init returns success; stub send avoids noisy drop stats
    - USB: default discrete queue len 1024; keep HWM/drop stats
    - TRS: remove mutex; sender task owns UART; uart_driver_install rx/tx buffers
    - Docs: document TRS>USB=BLE priority and PB/CC1 coalescing
2025-12-23 Adding Controls and Octave Change Feature
2025-12-23 Adding Stringwise Bend Mode Display
2025-12-23 fixing BLE Icon
2026-01-07 Adding BLE Docs
2026-01-09 Fix Kicad Data
2026-01-09 KiCad REV-B Design
2026-01-16 DEV-Aでテストしながら基板の改良
2026-01-16 save漏れ
2026-01-18 ロゴ追加
2026-01-19 キーマトリックスのスキャンを基板実装と整合
2026-01-19 一時ファイルを削除
2026-01-25 BOOTスイッチ修正
